<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f103xb.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>adc</name>
        <file>
          <name>$PROJ_DIR$\..\Src\adc\adc.c</name>
        </file>
      </group>
      <group>
        <name>ctrl</name>
        <file>
          <name>$PROJ_DIR$\..\Src\ctrl\gl_ctrl.c</name>
        </file>
      </group>
      <group>
        <name>flash</name>
        <file>
          <name>$PROJ_DIR$\..\Src\flash\flash_drv.c</name>
        </file>
      </group>
      <group>
        <name>hlog</name>
        <file>
          <name>$PROJ_DIR$\..\Src\hlog\hlog.c</name>
        </file>
      </group>
      <group>
        <name>manager</name>
        <file>
          <name>$PROJ_DIR$\..\Src\manager\distance_manager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\manager\gl_manager.c</name>
        </file>
      </group>
      <group>
        <name>misc_ro</name>
        <file>
          <name>$PROJ_DIR$\..\Src\misc_ro\misc_data_ro.c</name>
        </file>
      </group>
      <group>
        <name>misc_rw</name>
        <file>
          <name>$PROJ_DIR$\..\Src\misc_rw\misc_data_rw.c</name>
        </file>
      </group>
      <group>
        <name>power</name>
        <file>
          <name>$PROJ_DIR$\..\Src\power\power.c</name>
        </file>
      </group>
      <group>
        <name>pwm</name>
        <file>
          <name>$PROJ_DIR$\..\Src\pwm\pwm.c</name>
        </file>
      </group>
      <group>
        <name>shell</name>
        <file>
          <name>$PROJ_DIR$\..\Src\shell\shellTask.c</name>
        </file>
      </group>
      <group>
        <name>spk</name>
        <file>
          <name>$PROJ_DIR$\..\Src\spk\spk.c</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\..\Src\uart\trx485_if.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\uart\uart_485_drv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\uart\uart_debug_drv.c</name>
        </file>
      </group>
      <group>
        <name>unit</name>
        <file>
          <name>$PROJ_DIR$\..\Src\unit\unit.c</name>
        </file>
      </group>
      <group>
        <name>wdt</name>
        <file>
          <name>$PROJ_DIR$\..\Src\wdt\wdt.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\global.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\myprintf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\ring_buffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\rom_info.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f1xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f1xx_it.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Contiki</name>
    <group>
      <name>core</name>
      <group>
        <name>lib</name>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\lib\list.c</name>
        </file>
      </group>
      <group>
        <name>sys</name>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\autostart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\ctimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\etimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\process.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\procinit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\contiki\core\sys\timer.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>cpu</name>
      <file>
        <name>$PROJ_DIR$\..\contiki\cpu\arm\stm32f103\clock.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Src\system_stm32f1xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F1xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_uart.c</name>
      </file>
    </group>
  </group>
</project>


