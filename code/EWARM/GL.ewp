# IAR project GL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\contiki\core; ..\contiki\core\sys; ..\contiki\core\lib; ..\contiki\cpu\arm\stm32f103; ..\Src\uart; ..\Src\shell; ..\Src\flash; ..\Src\misc_ro; ..\Src\misc_rw; ..\Src\unit; ..\Src\wdt; ..\Src\adc; ..\Src\ctrl; ..\Src\spk; ..\Src\manager; ..\Src\hlog; ..\Src\power; ..\Src\pwm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GL.bin
  postbuild: post-build.bat "$TARGET_BPATH$" ..\Inc\rom_info.h Debug
  ILINK.IlinkOutputFile: GL.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkExtraOptions: --place_holder ielftool_checksum,2,checksum,4; --keep=ielftool_checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: global.c main.c myprintf.c ring_buffer.c rom_info.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/User/adc
    ../Src/adc/: adc.c
  group Application/User/ctrl
    ../Src/ctrl/: gl_ctrl.c
  group Application/User/flash
    ../Src/flash/: flash_drv.c
  group Application/User/hlog
    ../Src/hlog/: hlog.c
  group Application/User/manager
    ../Src/manager/: distance_manager.c gl_manager.c
  group Application/User/misc_ro
    ../Src/misc_ro/: misc_data_ro.c
  group Application/User/misc_rw
    ../Src/misc_rw/: misc_data_rw.c
  group Application/User/power
    ../Src/power/: power.c
  group Application/User/pwm
    ../Src/pwm/: pwm.c
  group Application/User/shell
    ../Src/shell/: shellTask.c
  group Application/User/spk
    ../Src/spk/: spk.c
  group Application/User/uart
    ../Src/uart/: trx485_if.c uart_485_drv.c uart_debug_drv.c
  group Application/User/unit
    ../Src/unit/: unit.c
  group Application/User/wdt
    ../Src/wdt/: wdt.c
  group Contiki/core/lib
    ../contiki/core/lib/: list.c
  group Contiki/core/sys
    ../contiki/core/sys/: autostart.c ctimer.c etimer.c process.c procinit.c timer.c
  group Contiki/cpu
    ../contiki/cpu/arm/stm32f103/: clock.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
